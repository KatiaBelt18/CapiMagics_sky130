VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO current_mirror
  CLASS BLOCK ;
  FOREIGN current_mirror ;
  ORIGIN 0.000 0.000 ;
  SIZE 22.700 BY 18.280 ;
  OBS
      LAYER nwell ;
        RECT 2.275 9.880 6.155 15.830 ;
        RECT 8.555 9.680 14.925 16.030 ;
      LAYER pwell ;
        RECT 2.180 7.910 6.250 8.580 ;
        RECT 2.180 6.635 2.850 7.910 ;
        RECT 5.580 6.635 6.250 7.910 ;
        RECT 2.180 4.375 6.250 6.635 ;
        RECT 2.180 3.100 2.850 4.375 ;
        RECT 5.580 3.100 6.250 4.375 ;
        RECT 2.180 2.430 6.250 3.100 ;
        RECT 9.010 7.910 20.520 8.580 ;
        RECT 9.010 6.635 9.680 7.910 ;
        RECT 19.850 6.635 20.520 7.910 ;
        RECT 9.010 4.375 20.520 6.635 ;
        RECT 9.010 3.100 9.680 4.375 ;
        RECT 19.850 3.100 20.520 4.375 ;
        RECT 9.010 2.430 20.520 3.100 ;
      LAYER li1 ;
        RECT 2.635 10.240 3.045 15.470 ;
        RECT 3.550 15.100 4.880 15.430 ;
        RECT 3.635 12.055 3.965 14.170 ;
        RECT 4.465 12.055 4.795 14.600 ;
        RECT 4.050 11.065 4.380 11.395 ;
        RECT 3.550 10.280 4.880 10.610 ;
        RECT 5.385 10.240 5.795 15.470 ;
        RECT 8.915 10.040 9.325 15.670 ;
        RECT 9.825 15.300 13.655 15.630 ;
        RECT 9.915 11.855 10.245 14.370 ;
        RECT 10.745 11.855 11.075 14.800 ;
        RECT 11.575 11.855 11.905 14.370 ;
        RECT 12.405 11.855 12.735 14.800 ;
        RECT 13.235 11.855 13.565 14.370 ;
        RECT 10.575 10.875 10.905 11.205 ;
        RECT 11.075 10.875 11.405 11.205 ;
        RECT 11.575 10.875 11.905 11.205 ;
        RECT 12.075 10.875 12.405 11.205 ;
        RECT 12.575 10.875 12.905 11.205 ;
        RECT 9.825 10.080 13.655 10.410 ;
        RECT 14.155 10.040 14.565 15.670 ;
        RECT 2.310 2.560 2.720 8.450 ;
        RECT 3.300 8.080 5.130 8.410 ;
        RECT 3.440 4.505 3.770 7.020 ;
        RECT 4.050 4.505 4.380 7.450 ;
        RECT 4.660 4.505 4.990 7.020 ;
        RECT 4.050 3.525 4.380 3.855 ;
        RECT 3.300 2.600 5.130 2.930 ;
        RECT 5.710 2.560 6.120 8.450 ;
        RECT 9.140 2.560 9.550 8.450 ;
        RECT 10.100 8.080 19.430 8.410 ;
        RECT 10.270 4.505 10.600 7.020 ;
        RECT 14.600 4.505 14.930 7.450 ;
        RECT 18.930 4.505 19.260 7.020 ;
        RECT 10.850 3.525 11.180 3.855 ;
        RECT 11.350 3.525 11.680 3.855 ;
        RECT 11.850 3.525 12.180 3.855 ;
        RECT 12.350 3.525 12.680 3.855 ;
        RECT 12.850 3.525 13.180 3.855 ;
        RECT 13.350 3.525 13.680 3.855 ;
        RECT 13.850 3.525 14.180 3.855 ;
        RECT 14.350 3.525 14.680 3.855 ;
        RECT 14.850 3.525 15.180 3.855 ;
        RECT 15.350 3.525 15.680 3.855 ;
        RECT 15.850 3.525 16.180 3.855 ;
        RECT 16.350 3.525 16.680 3.855 ;
        RECT 16.850 3.525 17.180 3.855 ;
        RECT 17.350 3.525 17.680 3.855 ;
        RECT 17.850 3.525 18.180 3.855 ;
        RECT 18.350 3.525 18.680 3.855 ;
        RECT 10.100 2.600 19.430 2.930 ;
        RECT 19.980 2.560 20.390 8.450 ;
      LAYER met1 ;
        RECT 3.045 17.315 14.155 17.745 ;
        RECT 3.045 15.470 5.385 17.315 ;
        RECT 9.325 15.670 14.155 17.315 ;
        RECT 2.635 15.060 5.795 15.470 ;
        RECT 8.915 15.260 14.565 15.670 ;
        RECT 15.755 14.860 16.185 15.000 ;
        RECT 1.550 14.370 4.775 14.660 ;
        RECT 9.935 14.570 16.185 14.860 ;
        RECT 1.550 14.230 1.980 14.370 ;
        RECT 3.655 13.940 5.795 14.230 ;
        RECT 9.935 14.140 14.565 14.430 ;
        RECT 3.655 12.055 3.945 13.655 ;
        RECT 4.485 12.055 4.775 13.655 ;
        RECT 9.935 11.855 10.225 13.855 ;
        RECT 10.765 11.855 11.055 13.855 ;
        RECT 11.595 11.855 11.885 13.855 ;
        RECT 12.425 11.855 12.715 13.855 ;
        RECT 13.255 11.855 13.545 13.855 ;
        RECT 1.550 11.065 4.465 11.395 ;
        RECT 15.720 11.205 16.150 11.255 ;
        RECT 1.550 10.965 1.980 11.065 ;
        RECT 10.245 10.875 16.150 11.205 ;
        RECT 15.720 10.825 16.150 10.875 ;
        RECT 2.635 10.240 5.795 10.650 ;
        RECT 8.915 10.040 14.565 10.450 ;
        RECT 7.860 9.540 8.290 9.680 ;
        RECT 13.325 9.540 13.755 9.610 ;
        RECT 1.500 8.850 7.230 9.280 ;
        RECT 7.860 9.250 16.185 9.540 ;
        RECT 13.325 9.180 13.755 9.250 ;
        RECT 15.755 9.110 16.185 9.250 ;
        RECT 2.310 8.040 6.120 8.450 ;
        RECT 9.140 8.040 20.390 8.450 ;
        RECT 1.550 7.510 1.980 7.650 ;
        RECT 1.550 7.220 4.970 7.510 ;
        RECT 7.860 7.220 19.240 7.510 ;
        RECT 7.860 7.080 8.290 7.220 ;
        RECT 3.460 6.790 6.120 7.080 ;
        RECT 10.290 6.790 20.390 7.080 ;
        RECT 3.460 4.505 3.750 6.505 ;
        RECT 4.070 4.505 4.360 6.505 ;
        RECT 4.680 4.505 4.970 6.505 ;
        RECT 1.550 3.855 1.980 3.955 ;
        RECT 6.265 3.855 7.765 5.025 ;
        RECT 10.290 4.505 10.580 6.505 ;
        RECT 14.620 4.505 14.910 6.505 ;
        RECT 18.950 4.505 19.240 6.505 ;
        RECT 1.550 3.525 4.660 3.855 ;
        RECT 6.265 3.525 18.930 3.855 ;
        RECT 2.310 2.560 6.120 2.970 ;
        RECT 9.140 2.560 20.390 2.970 ;
        RECT 2.720 0.965 5.710 2.560 ;
        RECT 9.550 0.965 19.980 2.560 ;
        RECT 2.720 0.535 19.980 0.965 ;
      LAYER met2 ;
        RECT 11.060 17.240 11.640 17.820 ;
        RECT 1.550 14.230 1.980 14.660 ;
        RECT 15.755 14.570 16.185 15.000 ;
        RECT 1.550 11.395 1.880 14.230 ;
        RECT 1.550 10.965 1.980 11.395 ;
        RECT 15.825 11.205 16.115 14.570 ;
        RECT 1.550 7.650 1.880 10.965 ;
        RECT 15.770 10.875 16.115 11.205 ;
        RECT 6.725 8.775 7.305 9.355 ;
        RECT 7.860 9.250 8.290 9.680 ;
        RECT 1.550 7.220 1.980 7.650 ;
        RECT 7.930 7.510 8.220 9.250 ;
        RECT 13.250 9.105 13.830 9.685 ;
        RECT 15.825 9.540 16.115 10.875 ;
        RECT 15.755 9.110 16.185 9.540 ;
        RECT 1.550 3.955 1.880 7.220 ;
        RECT 7.860 7.080 8.290 7.510 ;
        RECT 6.725 3.985 7.305 4.565 ;
        RECT 1.550 3.525 1.980 3.955 ;
        RECT 11.060 0.460 11.640 1.040 ;
      LAYER met3 ;
        RECT 10.600 16.780 12.100 18.280 ;
        RECT 6.265 3.525 7.765 9.815 ;
        RECT 12.790 8.645 14.290 10.145 ;
        RECT 10.600 0.000 12.100 1.500 ;
      LAYER met4 ;
        RECT 0.000 17.030 22.700 18.030 ;
        RECT 0.000 0.250 22.700 1.250 ;
  END
END current_mirror
END LIBRARY

