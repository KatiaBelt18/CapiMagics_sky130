VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO integrator
  CLASS BLOCK ;
  FOREIGN integrator ;
  ORIGIN 9.840 29.995 ;
  SIZE 79.920 BY 64.990 ;
  OBS
      LAYER Nwell ;
        RECT -3.840 27.935 3.840 32.065 ;
        RECT 11.160 27.935 18.840 32.065 ;
      LAYER Pwell ;
        RECT -3.840 -27.065 3.840 -22.935 ;
        RECT 11.160 -27.065 18.840 -22.935 ;
      LAYER Metal1 ;
        RECT -6.750 34.495 -6.250 34.995 ;
        RECT -5.450 34.495 5.450 34.995 ;
        RECT 6.250 34.495 6.750 34.995 ;
        RECT -6.750 25.505 -6.290 34.495 ;
        RECT 0.320 31.445 0.820 31.945 ;
        RECT -0.820 30.645 -0.320 31.145 ;
        RECT -3.420 28.855 -2.960 30.095 ;
        RECT -2.280 28.855 -1.820 30.095 ;
        RECT -0.800 29.845 -0.340 30.645 ;
        RECT 0.340 29.845 0.800 31.445 ;
        RECT -0.820 29.345 -0.320 29.845 ;
        RECT 0.320 29.345 0.820 29.845 ;
        RECT -0.800 29.095 -0.340 29.345 ;
        RECT 0.340 29.095 0.800 29.345 ;
        RECT -3.420 28.395 -1.820 28.855 ;
        RECT 1.820 28.855 2.280 30.095 ;
        RECT 2.960 28.855 3.420 30.095 ;
        RECT -0.250 28.055 0.250 28.555 ;
        RECT 1.820 28.395 3.420 28.855 ;
        RECT 6.290 25.505 6.750 34.495 ;
        RECT -6.750 25.005 -6.250 25.505 ;
        RECT -5.450 25.005 5.450 25.505 ;
        RECT 6.250 25.005 6.750 25.505 ;
        RECT 8.250 34.495 8.750 34.995 ;
        RECT 9.550 34.495 20.450 34.995 ;
        RECT 21.250 34.495 21.750 34.995 ;
        RECT 8.250 25.505 8.710 34.495 ;
        RECT 15.320 31.445 15.820 31.945 ;
        RECT 14.180 30.645 14.680 31.145 ;
        RECT 11.580 28.855 12.040 30.095 ;
        RECT 12.720 28.855 13.180 30.095 ;
        RECT 14.200 29.845 14.660 30.645 ;
        RECT 15.340 29.845 15.800 31.445 ;
        RECT 14.180 29.345 14.680 29.845 ;
        RECT 15.320 29.345 15.820 29.845 ;
        RECT 14.200 29.095 14.660 29.345 ;
        RECT 15.340 29.095 15.800 29.345 ;
        RECT 11.580 28.395 13.180 28.855 ;
        RECT 16.820 28.855 17.280 30.095 ;
        RECT 17.960 28.855 18.420 30.095 ;
        RECT 14.750 28.055 15.250 28.555 ;
        RECT 16.820 28.395 18.420 28.855 ;
        RECT 21.290 25.505 21.750 34.495 ;
        RECT 8.250 25.005 8.750 25.505 ;
        RECT 9.550 25.005 20.450 25.505 ;
        RECT 21.250 25.005 21.750 25.505 ;
        RECT -6.750 -20.505 -6.250 -20.005 ;
        RECT -5.450 -20.505 5.450 -20.005 ;
        RECT 6.250 -20.505 6.750 -20.005 ;
        RECT -6.750 -29.495 -6.290 -20.505 ;
        RECT 0.320 -23.555 0.820 -23.055 ;
        RECT -0.820 -24.355 -0.320 -23.855 ;
        RECT -3.420 -26.145 -2.960 -24.905 ;
        RECT -2.280 -26.145 -1.820 -24.905 ;
        RECT -0.800 -25.155 -0.340 -24.355 ;
        RECT 0.340 -25.155 0.800 -23.555 ;
        RECT -0.820 -25.655 -0.320 -25.155 ;
        RECT 0.320 -25.655 0.820 -25.155 ;
        RECT -0.800 -25.905 -0.340 -25.655 ;
        RECT 0.340 -25.905 0.800 -25.655 ;
        RECT -3.420 -26.605 -1.820 -26.145 ;
        RECT 1.820 -26.145 2.280 -24.905 ;
        RECT 2.960 -26.145 3.420 -24.905 ;
        RECT -0.250 -26.945 0.250 -26.445 ;
        RECT 1.820 -26.605 3.420 -26.145 ;
        RECT 6.290 -29.495 6.750 -20.505 ;
        RECT -6.750 -29.995 -6.250 -29.495 ;
        RECT -5.450 -29.995 5.450 -29.495 ;
        RECT 6.250 -29.995 6.750 -29.495 ;
        RECT 8.250 -20.505 8.750 -20.005 ;
        RECT 9.550 -20.505 20.450 -20.005 ;
        RECT 21.250 -20.505 21.750 -20.005 ;
        RECT 8.250 -29.495 8.710 -20.505 ;
        RECT 15.320 -23.555 15.820 -23.055 ;
        RECT 14.180 -24.355 14.680 -23.855 ;
        RECT 11.580 -26.145 12.040 -24.905 ;
        RECT 12.720 -26.145 13.180 -24.905 ;
        RECT 14.200 -25.155 14.660 -24.355 ;
        RECT 15.340 -25.155 15.800 -23.555 ;
        RECT 14.180 -25.655 14.680 -25.155 ;
        RECT 15.320 -25.655 15.820 -25.155 ;
        RECT 14.200 -25.905 14.660 -25.655 ;
        RECT 15.340 -25.905 15.800 -25.655 ;
        RECT 11.580 -26.605 13.180 -26.145 ;
        RECT 16.820 -26.145 17.280 -24.905 ;
        RECT 17.960 -26.145 18.420 -24.905 ;
        RECT 14.750 -26.945 15.250 -26.445 ;
        RECT 16.820 -26.605 18.420 -26.145 ;
        RECT 21.290 -29.495 21.750 -20.505 ;
        RECT 8.250 -29.995 8.750 -29.495 ;
        RECT 9.550 -29.995 20.450 -29.495 ;
        RECT 21.250 -29.995 21.750 -29.495 ;
      LAYER Metal2 ;
        RECT -6.750 34.495 6.750 34.995 ;
        RECT 8.250 34.495 21.750 34.995 ;
        RECT -0.820 31.445 1.820 31.945 ;
        RECT 14.180 31.445 15.820 31.945 ;
        RECT -0.820 30.645 15.820 31.145 ;
        RECT -0.820 29.920 -0.320 30.095 ;
        RECT 0.320 29.920 0.820 30.095 ;
        RECT 14.180 29.920 14.680 30.095 ;
        RECT 15.320 29.920 15.820 30.095 ;
        RECT -9.840 -9.840 70.080 29.920 ;
        RECT 12.230 -20.005 12.730 -9.840 ;
        RECT -6.750 -20.505 6.750 -20.005 ;
        RECT 8.250 -20.505 21.750 -20.005 ;
        RECT 12.230 -23.055 12.730 -20.505 ;
        RECT -0.820 -23.555 16.820 -23.055 ;
        RECT 12.230 -23.855 12.730 -23.555 ;
        RECT -0.820 -24.355 0.820 -23.855 ;
        RECT 12.230 -24.355 15.820 -23.855 ;
        RECT -0.820 -25.905 -0.320 -24.905 ;
        RECT 0.320 -25.905 0.820 -24.905 ;
        RECT 14.180 -25.905 14.680 -24.905 ;
        RECT 15.320 -25.905 15.820 -24.905 ;
        RECT -0.250 -26.945 0.250 -26.445 ;
        RECT 0.820 -26.945 16.820 -26.445 ;
        RECT -6.750 -29.995 6.750 -29.495 ;
        RECT 8.250 -29.995 21.750 -29.495 ;
      LAYER Metal3 ;
        RECT 1.320 29.920 1.820 31.945 ;
        RECT 12.230 29.920 12.730 31.145 ;
        RECT -9.840 -9.840 70.080 29.920 ;
        RECT 16.320 -26.945 16.820 -23.055 ;
  END
END integrator
END LIBRARY

