v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lif/neurona_input_current.sym} 55 45 0 0 {name=x2}
C {lif/neurona_input_current.sym} 55 295 0 0 {name=x3}
C {lif/neurona_input_current.sym} 55 525 0 0 {name=x4}
C {lif/neurona_input_current.sym} 55 765 0 0 {name=x5}
C {iopin.sym} -260 -20 0 0 {name=p1 lab=avdd}
C {iopin.sym} -260 20 0 0 {name=p2 lab=avss}
C {ipin.sym} -25 45 0 0 {name=p3 lab=Iext1}
C {ipin.sym} -25 295 0 0 {name=p4 lab=Iext2}
C {ipin.sym} -25 525 0 0 {name=p5 lab=Iext3}
C {ipin.sym} -25 765 0 0 {name=p6 lab=Iext4}
C {lab_pin.sym} 55 -35 0 0 {name=p7 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 55 215 0 0 {name=p8 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 55 445 0 0 {name=p9 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 55 685 0 0 {name=p10 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 55 125 0 0 {name=p11 sig_type=std_logic lab=avss}
C {lab_pin.sym} 55 375 0 0 {name=p12 sig_type=std_logic lab=avss}
C {lab_pin.sym} 55 605 0 0 {name=p13 sig_type=std_logic lab=avss}
C {lab_pin.sym} 55 845 0 0 {name=p14 sig_type=std_logic lab=avss}
C {opin.sym} 135 45 0 0 {name=p15 lab=vout_1}
C {opin.sym} 135 75 0 0 {name=p16 lab=nvout_1}
C {opin.sym} 135 295 0 0 {name=p17 lab=vout_2}
C {opin.sym} 135 325 0 0 {name=p18 lab=nvout_2}
C {opin.sym} 135 525 0 0 {name=p19 lab=vout_3}
C {opin.sym} 135 555 0 0 {name=p20 lab=nvout_3}
C {opin.sym} 135 765 0 0 {name=p21 lab=vout_4}
C {opin.sym} 135 795 0 0 {name=p22 lab=nvout_4}
