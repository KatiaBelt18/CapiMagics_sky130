VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO encoder
  CLASS BLOCK ;
  FOREIGN encoder ;
  ORIGIN 0.000 0.000 ;
  SIZE 47.340 BY 21.430 ;
  OBS
      LAYER nwell ;
        RECT 2.000 10.830 5.660 17.180 ;
        RECT 7.560 10.830 12.800 16.110 ;
        RECT 14.700 10.830 19.940 16.110 ;
        RECT 21.840 10.830 25.500 15.680 ;
        RECT 27.400 10.830 32.640 16.110 ;
        RECT 34.540 10.830 39.780 16.110 ;
        RECT 41.680 10.830 45.340 17.180 ;
      LAYER pwell ;
        RECT 2.180 7.410 15.360 8.080 ;
        RECT 2.180 6.135 2.850 7.410 ;
        RECT 14.690 6.135 15.360 7.410 ;
        RECT 2.180 5.375 15.360 6.135 ;
        RECT 2.180 4.100 2.850 5.375 ;
        RECT 14.690 4.100 15.360 5.375 ;
        RECT 2.180 3.430 15.360 4.100 ;
        RECT 17.620 7.410 21.080 8.080 ;
        RECT 17.620 6.135 18.290 7.410 ;
        RECT 20.410 6.135 21.080 7.410 ;
        RECT 17.620 5.375 21.080 6.135 ;
        RECT 17.620 4.100 18.290 5.375 ;
        RECT 20.410 4.100 21.080 5.375 ;
        RECT 17.620 3.430 21.080 4.100 ;
        RECT 23.340 7.410 26.800 8.080 ;
        RECT 23.340 6.135 24.010 7.410 ;
        RECT 26.130 6.135 26.800 7.410 ;
        RECT 23.340 5.375 26.800 6.135 ;
        RECT 23.340 4.100 24.010 5.375 ;
        RECT 26.130 4.100 26.800 5.375 ;
        RECT 23.340 3.430 26.800 4.100 ;
        RECT 29.060 7.410 42.240 8.080 ;
        RECT 29.060 6.135 29.730 7.410 ;
        RECT 41.570 6.135 42.240 7.410 ;
        RECT 29.060 5.375 42.240 6.135 ;
        RECT 29.060 4.100 29.730 5.375 ;
        RECT 41.570 4.100 42.240 5.375 ;
        RECT 29.060 3.430 42.240 4.100 ;
      LAYER li1 ;
        RECT 2.360 11.190 2.770 16.820 ;
        RECT 3.165 16.450 4.495 16.780 ;
        RECT 3.360 13.005 3.690 15.520 ;
        RECT 3.970 13.005 4.300 15.950 ;
        RECT 3.665 12.025 3.995 12.355 ;
        RECT 3.165 11.230 4.495 11.560 ;
        RECT 4.890 11.190 5.300 16.820 ;
        RECT 7.920 11.190 8.330 15.750 ;
        RECT 8.765 15.380 11.595 15.710 ;
        RECT 8.920 13.005 9.250 14.450 ;
        RECT 11.110 13.005 11.440 14.880 ;
        RECT 9.515 12.020 9.845 12.350 ;
        RECT 10.015 12.020 10.345 12.350 ;
        RECT 10.515 12.020 10.845 12.350 ;
        RECT 8.765 11.230 11.595 11.560 ;
        RECT 12.030 11.190 12.440 15.750 ;
        RECT 15.060 11.190 15.470 15.750 ;
        RECT 15.905 15.380 18.735 15.710 ;
        RECT 16.060 13.005 16.390 14.450 ;
        RECT 18.250 13.005 18.580 14.880 ;
        RECT 16.655 12.020 16.985 12.350 ;
        RECT 17.155 12.020 17.485 12.350 ;
        RECT 17.655 12.020 17.985 12.350 ;
        RECT 15.905 11.230 18.735 11.560 ;
        RECT 19.170 11.190 19.580 15.750 ;
        RECT 22.200 11.190 22.610 15.320 ;
        RECT 23.005 14.950 24.335 15.280 ;
        RECT 23.200 13.005 23.530 14.020 ;
        RECT 23.810 13.005 24.140 14.450 ;
        RECT 23.505 12.025 23.835 12.355 ;
        RECT 23.005 11.230 24.335 11.560 ;
        RECT 24.730 11.190 25.140 15.320 ;
        RECT 27.760 11.190 28.170 15.750 ;
        RECT 28.605 15.380 31.435 15.710 ;
        RECT 28.760 13.005 29.090 14.450 ;
        RECT 30.950 13.005 31.280 14.880 ;
        RECT 29.355 12.020 29.685 12.350 ;
        RECT 29.855 12.020 30.185 12.350 ;
        RECT 30.355 12.020 30.685 12.350 ;
        RECT 28.605 11.230 31.435 11.560 ;
        RECT 31.870 11.190 32.280 15.750 ;
        RECT 34.900 11.190 35.310 15.750 ;
        RECT 35.745 15.380 38.575 15.710 ;
        RECT 35.900 13.005 36.230 14.450 ;
        RECT 38.090 13.005 38.420 14.880 ;
        RECT 36.495 12.020 36.825 12.350 ;
        RECT 36.995 12.020 37.325 12.350 ;
        RECT 37.495 12.020 37.825 12.350 ;
        RECT 35.745 11.230 38.575 11.560 ;
        RECT 39.010 11.190 39.420 15.750 ;
        RECT 42.040 11.190 42.450 16.820 ;
        RECT 42.845 16.450 44.175 16.780 ;
        RECT 43.040 13.005 43.370 15.520 ;
        RECT 43.650 13.005 43.980 15.950 ;
        RECT 43.345 12.025 43.675 12.355 ;
        RECT 42.845 11.230 44.175 11.560 ;
        RECT 44.570 11.190 44.980 16.820 ;
        RECT 2.310 3.560 2.720 7.950 ;
        RECT 3.355 7.580 14.185 7.910 ;
        RECT 3.440 5.505 3.770 6.520 ;
        RECT 13.770 5.505 14.100 6.950 ;
        RECT 4.105 4.525 4.435 4.855 ;
        RECT 4.605 4.525 4.935 4.855 ;
        RECT 5.105 4.525 5.435 4.855 ;
        RECT 5.605 4.525 5.935 4.855 ;
        RECT 6.105 4.525 6.435 4.855 ;
        RECT 6.605 4.525 6.935 4.855 ;
        RECT 7.105 4.525 7.435 4.855 ;
        RECT 7.605 4.525 7.935 4.855 ;
        RECT 8.105 4.525 8.435 4.855 ;
        RECT 8.605 4.525 8.935 4.855 ;
        RECT 9.105 4.525 9.435 4.855 ;
        RECT 9.605 4.525 9.935 4.855 ;
        RECT 10.105 4.525 10.435 4.855 ;
        RECT 10.605 4.525 10.935 4.855 ;
        RECT 11.105 4.525 11.435 4.855 ;
        RECT 11.605 4.525 11.935 4.855 ;
        RECT 12.105 4.525 12.435 4.855 ;
        RECT 12.605 4.525 12.935 4.855 ;
        RECT 13.105 4.525 13.435 4.855 ;
        RECT 3.355 3.600 14.185 3.930 ;
        RECT 14.820 3.560 15.230 7.950 ;
        RECT 17.750 3.560 18.160 7.950 ;
        RECT 18.685 7.580 20.015 7.910 ;
        RECT 18.880 5.505 19.210 6.520 ;
        RECT 19.490 5.505 19.820 6.950 ;
        RECT 19.185 4.525 19.515 4.855 ;
        RECT 18.685 3.600 20.015 3.930 ;
        RECT 20.540 3.560 20.950 7.950 ;
        RECT 23.470 3.560 23.880 7.950 ;
        RECT 24.405 7.580 25.735 7.910 ;
        RECT 24.600 5.505 24.930 6.520 ;
        RECT 25.210 5.505 25.540 6.950 ;
        RECT 24.905 4.525 25.235 4.855 ;
        RECT 24.405 3.600 25.735 3.930 ;
        RECT 26.260 3.560 26.670 7.950 ;
        RECT 29.190 3.560 29.600 7.950 ;
        RECT 30.235 7.580 41.065 7.910 ;
        RECT 30.320 5.505 30.650 6.520 ;
        RECT 40.650 5.505 40.980 6.950 ;
        RECT 30.985 4.525 31.315 4.855 ;
        RECT 31.485 4.525 31.815 4.855 ;
        RECT 31.985 4.525 32.315 4.855 ;
        RECT 32.485 4.525 32.815 4.855 ;
        RECT 32.985 4.525 33.315 4.855 ;
        RECT 33.485 4.525 33.815 4.855 ;
        RECT 33.985 4.525 34.315 4.855 ;
        RECT 34.485 4.525 34.815 4.855 ;
        RECT 34.985 4.525 35.315 4.855 ;
        RECT 35.485 4.525 35.815 4.855 ;
        RECT 35.985 4.525 36.315 4.855 ;
        RECT 36.485 4.525 36.815 4.855 ;
        RECT 36.985 4.525 37.315 4.855 ;
        RECT 37.485 4.525 37.815 4.855 ;
        RECT 37.985 4.525 38.315 4.855 ;
        RECT 38.485 4.525 38.815 4.855 ;
        RECT 38.985 4.525 39.315 4.855 ;
        RECT 39.485 4.525 39.815 4.855 ;
        RECT 39.985 4.525 40.315 4.855 ;
        RECT 30.235 3.600 41.065 3.930 ;
        RECT 41.700 3.560 42.110 7.950 ;
      LAYER met1 ;
        RECT 2.770 20.465 44.570 20.895 ;
        RECT 2.770 16.820 4.890 20.465 ;
        RECT 2.360 16.410 5.300 16.820 ;
        RECT 0.950 16.010 1.380 16.150 ;
        RECT 0.950 15.720 4.280 16.010 ;
        RECT 8.330 15.750 12.030 20.465 ;
        RECT 15.470 15.750 19.170 20.465 ;
        RECT 3.380 15.290 5.300 15.580 ;
        RECT 7.920 15.340 12.440 15.750 ;
        RECT 15.060 15.340 19.580 15.750 ;
        RECT 22.610 15.320 24.730 20.465 ;
        RECT 28.170 15.750 31.870 20.465 ;
        RECT 35.310 15.750 39.010 20.465 ;
        RECT 42.450 16.820 44.570 20.465 ;
        RECT 42.040 16.410 44.980 16.820 ;
        RECT 45.460 16.010 45.890 16.150 ;
        RECT 27.760 15.340 32.280 15.750 ;
        RECT 34.900 15.340 39.420 15.750 ;
        RECT 43.060 15.720 45.890 16.010 ;
        RECT 3.380 13.005 3.670 15.005 ;
        RECT 3.990 13.005 4.280 15.005 ;
        RECT 12.705 14.940 13.135 15.010 ;
        RECT 19.845 14.940 20.275 15.010 ;
        RECT 8.940 14.650 13.135 14.940 ;
        RECT 16.080 14.650 20.275 14.940 ;
        RECT 22.200 14.910 25.140 15.320 ;
        RECT 43.060 15.290 44.980 15.580 ;
        RECT 32.545 14.940 32.975 15.010 ;
        RECT 39.685 14.940 40.115 15.010 ;
        RECT 28.780 14.650 32.975 14.940 ;
        RECT 35.920 14.650 40.115 14.940 ;
        RECT 12.705 14.580 13.135 14.650 ;
        RECT 19.845 14.580 20.275 14.650 ;
        RECT 21.290 14.510 21.720 14.650 ;
        RECT 27.020 14.510 27.450 14.650 ;
        RECT 32.545 14.580 32.975 14.650 ;
        RECT 39.685 14.580 40.115 14.650 ;
        RECT 8.940 14.220 12.440 14.510 ;
        RECT 16.080 14.220 19.580 14.510 ;
        RECT 21.290 14.220 27.450 14.510 ;
        RECT 28.780 14.220 32.280 14.510 ;
        RECT 35.920 14.220 39.420 14.510 ;
        RECT 8.940 13.005 9.230 13.935 ;
        RECT 11.130 13.005 11.420 13.935 ;
        RECT 16.080 13.005 16.370 13.935 ;
        RECT 18.270 13.005 18.560 13.935 ;
        RECT 23.220 13.790 25.140 14.080 ;
        RECT 23.220 13.005 23.510 13.505 ;
        RECT 23.830 13.005 24.120 13.505 ;
        RECT 28.780 13.005 29.070 13.935 ;
        RECT 30.970 13.005 31.260 13.935 ;
        RECT 35.920 13.005 36.210 13.935 ;
        RECT 38.110 13.005 38.400 13.935 ;
        RECT 43.060 13.005 43.350 15.005 ;
        RECT 43.670 13.005 43.960 15.005 ;
        RECT 3.665 12.350 9.250 12.355 ;
        RECT 3.665 12.335 18.250 12.350 ;
        RECT 23.505 12.335 23.835 12.355 ;
        RECT 43.345 12.350 43.675 12.355 ;
        RECT 0.950 12.045 18.250 12.335 ;
        RECT 0.950 11.905 1.380 12.045 ;
        RECT 3.665 12.025 18.250 12.045 ;
        RECT 9.250 12.020 18.250 12.025 ;
        RECT 21.290 12.045 23.835 12.335 ;
        RECT 21.290 11.905 21.720 12.045 ;
        RECT 23.505 12.025 23.835 12.045 ;
        RECT 29.090 12.335 43.675 12.350 ;
        RECT 29.090 12.045 45.890 12.335 ;
        RECT 29.090 12.025 43.675 12.045 ;
        RECT 29.090 12.020 43.345 12.025 ;
        RECT 45.460 11.905 45.890 12.045 ;
        RECT 2.360 11.190 5.300 11.600 ;
        RECT 7.920 11.190 12.440 11.600 ;
        RECT 15.060 11.190 19.580 11.600 ;
        RECT 22.200 11.190 25.140 11.600 ;
        RECT 27.760 11.190 32.280 11.600 ;
        RECT 34.900 11.190 39.420 11.600 ;
        RECT 42.040 11.190 44.980 11.600 ;
        RECT 15.815 9.480 16.245 9.530 ;
        RECT 28.175 9.480 28.605 9.530 ;
        RECT 15.815 9.150 28.605 9.480 ;
        RECT 15.815 9.100 16.245 9.150 ;
        RECT 28.175 9.100 28.605 9.150 ;
        RECT 2.310 7.540 15.230 7.950 ;
        RECT 17.750 7.540 20.950 7.950 ;
        RECT 23.470 7.540 26.670 7.950 ;
        RECT 29.190 7.540 42.110 7.950 ;
        RECT 22.690 7.010 23.120 7.150 ;
        RECT 0.950 6.720 14.080 7.010 ;
        RECT 15.915 6.720 19.800 7.010 ;
        RECT 22.690 6.720 27.450 7.010 ;
        RECT 30.340 6.720 45.890 7.010 ;
        RECT 0.950 6.580 1.380 6.720 ;
        RECT 15.915 6.650 16.345 6.720 ;
        RECT 15.865 6.580 16.345 6.650 ;
        RECT 27.020 6.580 27.450 6.720 ;
        RECT 28.125 6.580 28.555 6.650 ;
        RECT 45.460 6.580 45.890 6.720 ;
        RECT 3.460 6.290 16.295 6.580 ;
        RECT 18.900 6.290 20.950 6.580 ;
        RECT 24.620 6.290 26.670 6.580 ;
        RECT 28.125 6.290 40.960 6.580 ;
        RECT 15.865 6.220 16.295 6.290 ;
        RECT 28.125 6.220 28.555 6.290 ;
        RECT 3.460 5.505 3.750 6.005 ;
        RECT 13.790 5.505 14.080 6.005 ;
        RECT 18.900 5.505 19.190 6.005 ;
        RECT 19.510 5.505 19.800 6.005 ;
        RECT 24.620 5.505 24.910 6.005 ;
        RECT 25.230 5.505 25.520 6.005 ;
        RECT 30.340 5.505 30.630 6.005 ;
        RECT 40.670 5.505 40.960 6.005 ;
        RECT 3.805 4.855 4.235 4.905 ;
        RECT 30.685 4.855 31.115 4.905 ;
        RECT 3.770 4.525 13.770 4.855 ;
        RECT 19.185 4.525 25.235 4.855 ;
        RECT 30.650 4.525 40.650 4.855 ;
        RECT 3.805 4.475 4.235 4.525 ;
        RECT 22.690 4.405 23.120 4.525 ;
        RECT 30.685 4.475 31.115 4.525 ;
        RECT 2.310 3.560 15.230 3.970 ;
        RECT 17.750 3.560 20.950 3.970 ;
        RECT 23.470 3.560 26.670 3.970 ;
        RECT 29.190 3.560 42.110 3.970 ;
        RECT 2.720 0.965 14.820 3.560 ;
        RECT 18.160 0.965 20.540 3.560 ;
        RECT 23.880 0.965 26.260 3.560 ;
        RECT 29.600 0.965 41.700 3.560 ;
        RECT 2.720 0.535 41.700 0.965 ;
      LAYER met2 ;
        RECT 24.380 20.390 24.960 20.970 ;
        RECT 0.950 15.720 1.380 16.150 ;
        RECT 45.460 15.720 45.890 16.150 ;
        RECT 1.020 12.335 1.310 15.720 ;
        RECT 12.630 14.505 13.210 15.085 ;
        RECT 19.770 14.505 20.350 15.085 ;
        RECT 21.290 14.220 21.720 14.650 ;
        RECT 27.020 14.220 27.450 14.650 ;
        RECT 32.470 14.505 33.050 15.085 ;
        RECT 39.610 14.505 40.190 15.085 ;
        RECT 21.360 12.335 21.650 14.220 ;
        RECT 0.950 11.905 1.380 12.335 ;
        RECT 21.290 11.905 21.720 12.335 ;
        RECT 1.020 7.010 1.310 11.905 ;
        RECT 15.815 9.100 16.245 9.530 ;
        RECT 15.915 7.010 16.245 9.100 ;
        RECT 0.950 6.580 1.380 7.010 ;
        RECT 15.915 6.580 16.345 7.010 ;
        RECT 22.690 6.720 23.120 7.150 ;
        RECT 27.090 7.010 27.380 14.220 ;
        RECT 45.530 12.335 45.820 15.720 ;
        RECT 45.460 11.905 45.890 12.335 ;
        RECT 28.175 9.100 28.605 9.530 ;
        RECT 15.915 6.270 16.245 6.580 ;
        RECT 3.730 4.400 4.310 4.980 ;
        RECT 22.760 4.835 23.050 6.720 ;
        RECT 27.020 6.580 27.450 7.010 ;
        RECT 28.175 6.270 28.505 9.100 ;
        RECT 45.530 7.010 45.820 11.905 ;
        RECT 45.460 6.580 45.890 7.010 ;
        RECT 22.690 4.405 23.120 4.835 ;
        RECT 30.610 4.400 31.190 4.980 ;
        RECT 23.380 0.460 23.960 1.040 ;
      LAYER met3 ;
        RECT 23.920 19.930 25.420 21.430 ;
        RECT 12.170 14.045 13.670 15.545 ;
        RECT 19.310 14.045 20.810 15.545 ;
        RECT 32.010 14.045 33.510 15.545 ;
        RECT 39.150 14.045 40.650 15.545 ;
        RECT 3.270 3.940 4.770 5.440 ;
        RECT 30.150 3.940 31.650 5.440 ;
        RECT 22.920 0.000 24.420 1.500 ;
      LAYER met4 ;
        RECT 0.000 20.180 47.340 21.180 ;
        RECT 0.000 0.250 47.340 1.250 ;
  END
END encoder
END LIBRARY

